# Keil uVision project task4_stm32.uvprojx, settings and files
target STM32F103C8_Task4 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: task4_stm32 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c misc: --c99
  library: MicroLIB
  group Application
    ./: main.c ssd1306.c ssd1306.h stm32f103c8_regs.h
  group Startup
    ./: startup_stm32f103c8_keil.s
